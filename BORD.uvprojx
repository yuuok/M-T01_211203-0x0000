# Keil uVision project BORD.uvprojx, settings and files
target Board (6160000::V6.16::ARMCLANG)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: BORD +hex
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=4
  c include: .\SOURCE;.\SOURCE\MAIN\INC;.\SOURCE\HAL\ONCHIP\INC;.\SOURCE\HAL\ONBOARD\INC;.\SOURCE\APP\INC;.\SOURCE\API\INC;.\SOURCE\MAIN;.\SOURCE\HAL;.\SOURCE\APP;.\SOURCE\API;.\RTE\Device\STM32F103C8
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group MAIN
    ./SOURCE/MAIN/: main.c
  group HAL_CHIP
    ./SOURCE/HAL/ONCHIP/: rcc.c gpio.c nvic.c timer.c iwdg.c pwmTim1.c adc.c dma.c
  group API
    ./SOURCE/API/: common.c parameters.c event.c formatPrint.c irq_base_handler.c mc_cal.c
  group APP
    ./SOURCE/APP/: motorControl.c
software components: CMSIS:CORE 5.4.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:ADC 3.5.0, Device:StdPeriph Drivers:DMA 3.5.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:IWDG 3.5.0, Device:StdPeriph Drivers:PWR 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0
